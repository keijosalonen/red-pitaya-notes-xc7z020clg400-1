## tmp/linux-6.6/drivers/net/wireless/realtek/rtl8188eu/Kconfig
```kconfig
config RTL8188EU
	tristate "Realtek 8188E USB WiFi"
	depends on MAC80211 && USB
	help
	  Help message of RTL8188EU
```
